# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F4
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS;..\User;..\User\led;..\User\usart;..\User\I2C;..\User\MPU6050;..\User\systick;..\User\Font;..\User\SPI-FLASH;..\User\LCD;..\User\DMP\driver\eMPL;..\User\DMP\driver\include;..\User\DMP\driver\stm32L;..\User\DMP\eMPL-hal;..\User\DMP\mllite;..\User\DMP\mpl;..\User\EXTI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/led/: bps_led.c
    ../User/usart/: bps_usart.c
    ../User/I2C/: bps_HW_i2c.c bps_SW_i2c.c
    ../User/systick/: bps_systick.c
    ../User/Font/: bps_Font.c
    ../User/LCD/: bps_ili9341_lcd.c
    ../User/SPI-FLASH/: bps_flash.c
    ../User/MPU6050/: bps_mpu6050.c
    ../User/EXTI/: bps_exti.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DOC
    ../Doc/: readme.txt
  group MPU_eMPL
    ../User/DMP/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../User/DMP/driver/stm32L/: log_stm32.c
    ../User/DMP/eMPL-hal/: eMPL_outputs.c
  group MPU_mllite
    ../User/DMP/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group MPU_mpl
    ../User/DMP/mpl/: libmpllib.lib
